options:
  parameters:
    category: Custom
    description: 'Simulated channel + receiver: echo delay, noise, matched filter. Matches 03-hardware.md 2.2.'
    generate_options: qt_gui
    id: radar_rx_sim
    output_language: python
    title: Radar Receiver (simulated channel + matched filter)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Sampling rate (RadarConfig.fs_hz)
    value: 20e6
  states: {}
- name: fc
  id: variable
  parameters:
    comment: 'Carrier frequency - baseband 0 (01-physics.md: complex baseband)'
    value: '0'
  states: {}
- name: bandwidth_hz
  id: variable
  parameters:
    comment: Chirp bandwidth
    value: 5e6
  states: {}
- name: pulse_width_s
  id: variable
  parameters:
    comment: Pulse width
    value: '20e-6'
  states: {}
- name: pri_s
  id: variable
  parameters:
    comment: Pulse repetition interval
    value: '1e-3'
  states: {}
- name: n_pulse_samp
  id: variable
  parameters:
    comment: Samples per pulse
    value: int(pulse_width_s*samp_rate)
  states: {}
- name: n_pri_samp
  id: variable
  parameters:
    comment: Samples per PRI
    value: int(pri_s*samp_rate)
  states: {}
- name: c
  id: variable
  parameters:
    comment: Speed of light (m/s)
    value: 3e8
  states: {}
- name: range_m
  id: variable
  parameters:
    comment: Target range (m) - the R=1000 m test case
    value: '1000'
  states: {}
- name: n_delay
  id: variable
  parameters:
    comment: 'Round-trip delay in samples: round(2R/c * fs) = 133'
    value: int(round(2*range_m/c*samp_rate))
  states: {}
- name: noise_amp
  id: variable
  parameters:
    comment: Noise amplitude (receiver noise floor, ~20 dB SNR)
    value: '0.05'
  states: {}
- name: radar_taps
  id: epy_module
  parameters:
    source_code: |-
      """Radar waveform helpers for the GNU Radio flowgraphs.

      LEARNER TASK (05-roadmap.md stage 2 / 03-hardware.md 2.1-2.2):
      implement chirp(), pulse_vector() and matched() below so the
      flowgraphs can be generated and run. These mirror
      src/radar/signal_gen.py. All functions must return numpy complex128
      arrays; GRC converts them to gr_complex. See
      docs/training/01-physics.md section 2 (LFM) for the math.
      """

      import numpy as np


      def chirp(samp_rate=20e6, pulse_width_s=20e-6, bandwidth_hz=5e6, fc_hz=0.0):
          """Complex analytic LFM chirp, one pulse of fast-time samples.

          slope = bandwidth_hz / pulse_width_s
          return np.exp(1j * 2 * np.pi * (fc_hz * t + 0.5 * slope * t**2))
          with t = arange(int(pulse_width_s*samp_rate)) / samp_rate.
          """
          raise NotImplementedError(
              'Implement chirp() (05-roadmap.md stage 2)')


      def pulse_vector(samp_rate=20e6, pulse_width_s=20e-6, pri_s=1e-3,
                       bandwidth_hz=5e6, fc_hz=0.0):
          """One PRI: LFM chirp followed by the quiet window (zeros).

          np.concatenate([chirp(...), np.zeros(n_pri - n_pulse)]).
          """
          raise NotImplementedError(
              'Implement pulse_vector() (05-roadmap.md stage 2)')


      def matched(samp_rate=20e6, pulse_width_s=20e-6, bandwidth_hz=5e6):
          """Matched-filter taps: conjugated, time-reversed chirp.

          np.conj(chirp(...)[::-1]). Convolving with the echo gives the
          compressed pulse (range resolution c/(2B)).
          """
          raise NotImplementedError(
              'Implement matched() (05-roadmap.md stage 4)')
    comment: Radar waveform helpers (pulse_vector, matched)
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: TX waveform copy = pulsed LFM chirp (transmit_waveform)
    repeat: 'True'
    type: complex
    vector: radar_taps.pulse_vector()
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Round-trip propagation delay (channel.propagate)
    delay: n_delay
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    comment: Receiver noise (channel noise)
    noise_type: analog.GR_GAUSSIAN
    amp: noise_amp
    seed: '42'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Echo + noise (simulate_channel)
    type: complex
  states: {}
- name: filter_fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: 'Matched filter: taps = conj(time-reversed chirp) (receiver.matched_filter)'
    decim: '1'
    taps: radar_taps.matched()
    type: ccc
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: Envelope for display / peak detection
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: '"Received echo (RX input)"'
    size: '1024'
    srate: samp_rate
    ymin: '-1.5'
    ymax: '1.5'
    gui_hint: 0,0,1,1
    label1: I
    label2: Q
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '"Matched filter output (envelope)"'
    size: '1024'
    srate: samp_rate
    ymin: '-10'
    ymax: '500'
    gui_hint: 1,0,1,1
    label1: matched
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: float
    name: '"Matched filter spectrum"'
    fftsize: '1024'
    fc: fc
    bw: samp_rate
    gui_hint: 0,1,1,1
  states: {}

connections:
- [blocks_vector_source_x_0, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', filter_fir_filter_xxx_0, '0']
- [filter_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
