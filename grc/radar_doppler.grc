options:
  parameters:
    category: Custom
    description: 'Range-Doppler map: slow-time FFT across pulses. Matches 03-hardware.md 2.3.'
    generate_options: qt_gui
    id: radar_doppler
    output_language: python
    title: Radar Range-Doppler Map
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Sampling rate (RadarConfig.fs_hz)
    value: 20e6
  states: {}
- name: fc
  id: variable
  parameters:
    comment: Carrier frequency for display - baseband 0
    value: '0'
  states: {}
- name: fc_rf
  id: variable
  parameters:
    comment: RF carrier used for Doppler math (2.45 GHz, ISM band)
    value: 2.45e9
  states: {}
- name: bandwidth_hz
  id: variable
  parameters:
    comment: Chirp bandwidth
    value: 5e6
  states: {}
- name: pulse_width_s
  id: variable
  parameters:
    comment: Pulse width
    value: '20e-6'
  states: {}
- name: pri_s
  id: variable
  parameters:
    comment: Pulse repetition interval
    value: '1e-3'
  states: {}
- name: n_pulse_samp
  id: variable
  parameters:
    comment: Samples per pulse
    value: int(pulse_width_s*samp_rate)
  states: {}
- name: n_pri_samp
  id: variable
  parameters:
    comment: Samples per PRI
    value: int(pri_s*samp_rate)
  states: {}
- name: c
  id: variable
  parameters:
    comment: Speed of light (m/s)
    value: 3e8
  states: {}
- name: range_m
  id: variable
  parameters:
    comment: Target range (m) - the R=1000 m test case
    value: '1000'
  states: {}
- name: n_delay
  id: variable
  parameters:
    comment: 'Round-trip delay in samples: round(2R/c * fs) = 133'
    value: int(round(2*range_m/c*samp_rate))
  states: {}
- name: noise_amp
  id: variable
  parameters:
    comment: Noise amplitude (~20 dB SNR)
    value: '0.05'
  states: {}
- name: n_pulses
  id: variable
  parameters:
    comment: Pulses per coherent processing interval (RadarConfig.n_pulses)
    value: '64'
  states: {}
- name: n_win
  id: variable
  parameters:
    comment: Fast-time listen window per pulse (pulse + echo guard)
    value: int(1.5*pulse_width_s*samp_rate)
  states: {}
- name: target_velocity_mps
  id: variable
  parameters:
    comment: Target radial velocity (m/s) - the v=40 m/s test case
    value: '40'
  states: {}
- name: doppler_phase_incr
  id: variable
  parameters:
    comment: Per-pulse phase advance = 2*pi*f_d*PRI, f_d = 2v/lambda
    value: 2*3.141592653589793*2*target_velocity_mps*fc_rf/c*pri_s
  states: {}
- name: radar_taps
  id: epy_module
  parameters:
    source_code: |-
      """Radar waveform helpers for the GNU Radio flowgraphs.

      LEARNER TASK (05-roadmap.md stage 2 / 03-hardware.md 2.1-2.2):
      implement chirp(), pulse_vector() and matched() below so the
      flowgraphs can be generated and run. These mirror
      src/radar/signal_gen.py. All functions must return numpy complex128
      arrays; GRC converts them to gr_complex. See
      docs/training/01-physics.md section 2 (LFM) for the math.
      """

      import numpy as np


      def chirp(samp_rate=20e6, pulse_width_s=20e-6, bandwidth_hz=5e6, fc_hz=0.0):
          """Complex analytic LFM chirp, one pulse of fast-time samples.

          slope = bandwidth_hz / pulse_width_s
          return np.exp(1j * 2 * np.pi * (fc_hz * t + 0.5 * slope * t**2))
          with t = arange(int(pulse_width_s*samp_rate)) / samp_rate.
          """
          raise NotImplementedError(
              'Implement chirp() (05-roadmap.md stage 2)')


      def pulse_vector(samp_rate=20e6, pulse_width_s=20e-6, pri_s=1e-3,
                       bandwidth_hz=5e6, fc_hz=0.0):
          """One PRI: LFM chirp followed by the quiet window (zeros).

          np.concatenate([chirp(...), np.zeros(n_pri - n_pulse)]).
          """
          raise NotImplementedError(
              'Implement pulse_vector() (05-roadmap.md stage 2)')


      def matched(samp_rate=20e6, pulse_width_s=20e-6, bandwidth_hz=5e6):
          """Matched-filter taps: conjugated, time-reversed chirp.

          np.conj(chirp(...)[::-1]). Convolving with the echo gives the
          compressed pulse (range resolution c/(2B)).
          """
          raise NotImplementedError(
              'Implement matched() (05-roadmap.md stage 4)')
    comment: Radar waveform helpers (pulse_vector, matched)
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: TX waveform copy = pulsed LFM chirp
    repeat: 'True'
    type: complex
    vector: radar_taps.pulse_vector()
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Round-trip propagation delay (channel)
    delay: n_delay
    type: complex
  states: {}
- name: doppler_phase
  id: epy_block
  parameters:
    _source_code: |-
      """Doppler phase ramp across pulses.

      LEARNER TASK (05-roadmap.md stage 7): implement work().

      Applies a constant per-pulse phase advance to the delayed echo,
      modelling the target's radial velocity. The phase advances once per
      pulse: phase_increment_rad = 2*pi*f_d*PRI with f_d = 2*v/lambda.
      See docs/training/01-physics.md section 4. The leakage path (direct
      TX-to-RX) is NOT rotated, so it stays at zero Doppler.
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Apply a slow-time phase ramp (once per samples_per_pulse samples)."""

          def __init__(self, samples_per_pulse=20000,
                       phase_increment_rad=4.1050144006906635):
              gr.sync_block.__init__(
                  self,
                  name='Doppler Phase Ramp',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
              )
              self.samples_per_pulse = int(samples_per_pulse)
              self.increment = float(phase_increment_rad)
              self.idx_in_pulse = 0
              self.phase = 0.0

          def work(self, input_items, output_items):
              """Rotate every input sample by the current pulse's phase.

              Learner task (05-roadmap.md stage 7 / 03-hardware.md 2.3):
              apply exp(j*phase) per sample, advancing phase by
              phase_increment_rad once per samples_per_pulse samples.
              Return the number of samples written.
              """
              raise NotImplementedError(
                  'Implement work() (05-roadmap.md stage 7)')
    samples_per_pulse: '20000'
    phase_increment_rad: '4.1050144006906635'
    comment: Per-pulse Doppler phase (moving target, v=40 m/s)
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    comment: Receiver noise
    noise_type: analog.GR_GAUSSIAN
    amp: noise_amp
    seed: '42'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Leakage (0) + moving echo (1) + noise (2)
    num_inputs: '3'
    type: complex
  states: {}
- name: filter_fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Matched filter (receiver.matched_filter)
    decim: '1'
    taps: radar_taps.matched()
    type: ccc
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    comment: Extract the n_win-sample fast-time window of each PRI
    m: n_win
    n: n_pri_samp
    offset: '0'
    type: complex
  states: {}
- name: range_doppler
  id: epy_block
  parameters:
    _source_code: |-
      """Range-Doppler map: slow-time FFT over the buffered pulse matrix.

      LEARNER TASK (05-roadmap.md stage 7): implement work().

      Input is the matched-filter stream for one fast-time window per pulse
      (blocks_keep_m_in_n makes the pulses back-to-back). Every
      n_pulses*PULSE samples the block reshapes into a [pulse x range]
      matrix, FFTs along slow time (pulse axis), shifts the Doppler axis and
      emits the magnitude map row by row (doppler x range) for the raster
      sink. Mirrors doppler.range_doppler_map in the Python sim.
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """2-D range-Doppler map from the matched-filter stream.

          Must be a gr.sync_block (a gateway class) for GRC to use it as an
          epy_block; gr.block is not accepted.
          """

          def __init__(self, n_pulses=64, samples_per_pulse=600):
              gr.sync_block.__init__(
                  self,
                  name='Range-Doppler Map',
                  in_sig=[np.complex64],
                  out_sig=[np.float32],
              )
              self.n_pulses = int(n_pulses)
              self.samples_per_pulse = int(samples_per_pulse)
              self.frame = self.n_pulses * self.samples_per_pulse
              self.norm = float(self.frame)
              self.buffer = np.zeros(0, dtype=np.complex64)
              self.pending = np.zeros(0, dtype=np.float32)

          def work(self, input_items, output_items):
              """Buffer, FFT over slow time per frame, emit magnitude rows.

              Learner task (05-roadmap.md stage 7 / 03-hardware.md 2.3):
              append the input to self.buffer; while len(buffer) >= frame,
              reshape into [pulses x ranges], FFT along the pulse axis,
              fftshift the Doppler axis, take |.|, normalise by self.norm
              and emit rows (doppler x range) for the raster sink.
              Return the number of samples written. The __init__ above
              already sets up in/out sigs, the frame size and buffers.
              """
              raise NotImplementedError(
                  'Implement work() (05-roadmap.md stage 7)')
    n_pulses: '64'
    samples_per_pulse: '600'
    comment: 2-D range-Doppler map (doppler.range_doppler_map)
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    type: float
    name: '"Range-Doppler map"'
    samp_rate: samp_rate
    nrows: n_pulses
    ncols: n_win
    x_label: Range bin
    x_start_value: '0'
    x_end_value: n_win
    y_label: Doppler bin
    y_start_value: '0'
    y_end_value: n_pulses
    grid: 'True'
    zmin: '0'
    gui_hint: 0,0,1,1
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: '"Matched filter output"'
    size: '1024'
    srate: samp_rate
    ymin: '-10'
    ymax: '500'
    gui_hint: 1,0,1,1
    label1: I
    label2: Q
  states: {}

connections:
- [blocks_vector_source_x_0, '0', blocks_delay_0, '0']
- [blocks_vector_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_delay_0, '0', doppler_phase, '0']
- [doppler_phase, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', filter_fir_filter_xxx_0, '0']
- [filter_fir_filter_xxx_0, '0', blocks_keep_m_in_n_0, '0']
- [filter_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_m_in_n_0, '0', range_doppler, '0']
- [range_doppler, '0', qtgui_time_raster_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
