options:
  parameters:
    category: Custom
    description: '4-element ULA: arrival phases, steering weights, coherent combine. Matches 03-hardware.md 2.4.'
    generate_options: qt_gui
    id: radar_array
    output_language: python
    title: Radar Array Beamforming (4-element ULA)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Sampling rate (RadarConfig.fs_hz)
    value: 20e6
  states: {}
- name: fc
  id: variable
  parameters:
    comment: Carrier frequency for display - baseband 0
    value: '0'
  states: {}
- name: fc_rf
  id: variable
  parameters:
    comment: RF carrier used for array geometry (2.45 GHz)
    value: 2.45e9
  states: {}
- name: bandwidth_hz
  id: variable
  parameters:
    comment: Chirp bandwidth
    value: 5e6
  states: {}
- name: pulse_width_s
  id: variable
  parameters:
    comment: Pulse width
    value: '20e-6'
  states: {}
- name: pri_s
  id: variable
  parameters:
    comment: Pulse repetition interval
    value: '1e-3'
  states: {}
- name: n_pulse_samp
  id: variable
  parameters:
    comment: Samples per pulse
    value: int(pulse_width_s*samp_rate)
  states: {}
- name: n_pri_samp
  id: variable
  parameters:
    comment: Samples per PRI
    value: int(pri_s*samp_rate)
  states: {}
- name: c
  id: variable
  parameters:
    comment: Speed of light (m/s)
    value: 3e8
  states: {}
- name: range_m
  id: variable
  parameters:
    comment: Target range (m) - the R=1000 m test case
    value: '1000'
  states: {}
- name: n_delay
  id: variable
  parameters:
    comment: 'Round-trip delay in samples: round(2R/c * fs) = 133'
    value: int(round(2*range_m/c*samp_rate))
  states: {}
- name: noise_amp
  id: variable
  parameters:
    comment: Per-element noise amplitude
    value: '0.05'
  states: {}
- name: n_elements
  id: variable
  parameters:
    comment: Array elements (RadarConfig.n_elements)
    value: '4'
  states: {}
- name: d_over_lambda
  id: variable
  parameters:
    comment: Element spacing / wavelength (half-wavelength ULA)
    value: '0.5'
  states: {}
- name: theta_deg
  id: variable
  parameters:
    comment: Target angle off boresight (deg) - the theta=20 deg test case
    value: '20'
  states: {}
- name: theta_rad
  id: variable
  parameters:
    comment: Target angle in radians (used by gen_weights.py; the phases below are precomputed for GRC)
    value: theta_deg*3.141592653589793/180
  states: {}
- name: phi_m0
  id: variable
  parameters:
    comment: Arrival phase element 0
    value: '0'
  states: {}
- name: phi_m1
  id: variable
  parameters:
    comment: Arrival phase element 1 = 2*pi*d/lambda*sin(theta) = 1.0745 rad (grcc cannot evaluate sin(); see grc/gen_weights.py)
    value: '1.07448797'
  states: {}
- name: phi_m2
  id: variable
  parameters:
    comment: Arrival phase element 2 = 2.14897594 rad
    value: '2.14897594'
  states: {}
- name: phi_m3
  id: variable
  parameters:
    comment: Arrival phase element 3 = 3.22346391 rad
    value: '3.22346391'
  states: {}
- name: radar_taps
  id: epy_module
  parameters:
    source_code: |-
      """Radar waveform helpers for the GNU Radio flowgraphs.

      LEARNER TASK (05-roadmap.md stage 2 / 03-hardware.md 2.1-2.2):
      implement chirp(), pulse_vector() and matched() below so the
      flowgraphs can be generated and run. These mirror
      src/radar/signal_gen.py. All functions must return numpy complex128
      arrays; GRC converts them to gr_complex. See
      docs/training/01-physics.md section 2 (LFM) for the math.
      """

      import numpy as np


      def chirp(samp_rate=20e6, pulse_width_s=20e-6, bandwidth_hz=5e6, fc_hz=0.0):
          """Complex analytic LFM chirp, one pulse of fast-time samples.

          slope = bandwidth_hz / pulse_width_s
          return np.exp(1j * 2 * np.pi * (fc_hz * t + 0.5 * slope * t**2))
          with t = arange(int(pulse_width_s*samp_rate)) / samp_rate.
          """
          raise NotImplementedError(
              'Implement chirp() (05-roadmap.md stage 2)')


      def pulse_vector(samp_rate=20e6, pulse_width_s=20e-6, pri_s=1e-3,
                       bandwidth_hz=5e6, fc_hz=0.0):
          """One PRI: LFM chirp followed by the quiet window (zeros).

          np.concatenate([chirp(...), np.zeros(n_pri - n_pulse)]).
          """
          raise NotImplementedError(
              'Implement pulse_vector() (05-roadmap.md stage 2)')


      def matched(samp_rate=20e6, pulse_width_s=20e-6, bandwidth_hz=5e6):
          """Matched-filter taps: conjugated, time-reversed chirp.

          np.conj(chirp(...)[::-1]). Convolving with the echo gives the
          compressed pulse (range resolution c/(2B)).
          """
          raise NotImplementedError(
              'Implement matched() (05-roadmap.md stage 4)')
    comment: Radar waveform helpers (pulse_vector, matched)
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Element 0 TX waveform copy
    repeat: 'True'
    type: complex
    vector: radar_taps.pulse_vector()
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    comment: Element 1 TX waveform copy
    repeat: 'True'
    type: complex
    vector: radar_taps.pulse_vector()
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    comment: Element 2 TX waveform copy
    repeat: 'True'
    type: complex
    vector: radar_taps.pulse_vector()
  states: {}
- name: blocks_vector_source_x_3
  id: blocks_vector_source_x
  parameters:
    comment: Element 3 TX waveform copy
    repeat: 'True'
    type: complex
    vector: radar_taps.pulse_vector()
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Element 0 arrival phase (exp(j*phi_m0) = 1)
    const: (1+0j)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Element 1 arrival phase (exp(j*phi_m1))
    const: (0.47618+0.87935j)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: Element 2 arrival phase (exp(j*phi_m2))
    const: (-0.54650+0.83746j)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    comment: Element 3 arrival phase (exp(j*phi_m3))
    const: (-0.99665-0.08178j)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    comment: Steering weight m0 = conj(exp(j*phi_m0))
    const: (1-0j)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_5
  id: blocks_multiply_const_vxx
  parameters:
    comment: Steering weight m1 = conj(exp(j*phi_m1))
    const: (0.47618-0.87935j)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_6
  id: blocks_multiply_const_vxx
  parameters:
    comment: Steering weight m2 = conj(exp(j*phi_m2))
    const: (-0.54650-0.83746j)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_7
  id: blocks_multiply_const_vxx
  parameters:
    comment: Steering weight m3 = conj(exp(j*phi_m3))
    const: (-0.99665+0.08178j)
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    comment: Element 0 receiver noise (independent seed)
    noise_type: analog.GR_GAUSSIAN
    amp: noise_amp
    seed: '1'
    type: complex
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    comment: Element 1 receiver noise (independent seed)
    noise_type: analog.GR_GAUSSIAN
    amp: noise_amp
    seed: '2'
    type: complex
  states: {}
- name: analog_noise_source_x_2
  id: analog_noise_source_x
  parameters:
    comment: Element 2 receiver noise (independent seed)
    noise_type: analog.GR_GAUSSIAN
    amp: noise_amp
    seed: '3'
    type: complex
  states: {}
- name: analog_noise_source_x_3
  id: analog_noise_source_x
  parameters:
    comment: Element 3 receiver noise (independent seed)
    noise_type: analog.GR_GAUSSIAN
    amp: noise_amp
    seed: '4'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: 'Element 0: weighted signal + noise'
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    comment: 'Element 1: weighted signal + noise'
    type: complex
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    comment: 'Element 2: weighted signal + noise'
    type: complex
  states: {}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    comment: 'Element 3: weighted signal + noise'
    type: complex
  states: {}
- name: blocks_add_xx_4
  id: blocks_add_xx
  parameters:
    comment: Coherent combine (beamformer.cbf_weights) - 10log10(4) ~ 6 dB SNR gain
    num_inputs: '4'
    type: complex
  states: {}
- name: filter_fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Matched filter (receiver.matched_filter)
    decim: '1'
    taps: radar_taps.matched()
    type: ccc
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: Envelope for display
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '"Beamformer output (envelope)"'
    size: '1024'
    srate: samp_rate
    ymin: '-10'
    ymax: '1500'
    gui_hint: 0,0,1,1
    label1: beam
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: float
    name: '"Beamformer spectrum"'
    fftsize: '1024'
    fc: fc
    bw: samp_rate
    gui_hint: 0,1,1,1
  states: {}

connections:
- [blocks_vector_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_source_x_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_vector_source_x_2, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_vector_source_x_3, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_4, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_const_vxx_5, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_const_vxx_6, '0']
- [blocks_multiply_const_vxx_3, '0', blocks_multiply_const_vxx_7, '0']
- [blocks_multiply_const_vxx_4, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_5, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_6, '0', blocks_add_xx_2, '0']
- [blocks_multiply_const_vxx_7, '0', blocks_add_xx_3, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_1, '0', blocks_add_xx_1, '1']
- [analog_noise_source_x_2, '0', blocks_add_xx_2, '1']
- [analog_noise_source_x_3, '0', blocks_add_xx_3, '1']
- [blocks_add_xx_0, '0', blocks_add_xx_4, '0']
- [blocks_add_xx_1, '0', blocks_add_xx_4, '1']
- [blocks_add_xx_2, '0', blocks_add_xx_4, '2']
- [blocks_add_xx_3, '0', blocks_add_xx_4, '3']
- [blocks_add_xx_4, '0', filter_fir_filter_xxx_0, '0']
- [filter_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
