options:
  parameters:
    category: Custom
    description: 'Transmit waveform: pulsed LFM chirp. Matches 03-hardware.md 2.1.'
    generate_options: qt_gui
    id: radar_tx
    output_language: python
    title: Radar Transmitter (pulsed LFM chirp)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Sampling rate (04-python-discipline.md RadarConfig.fs_hz)
    value: 20e6
  states: {}
- name: fc
  id: variable
  parameters:
    comment: Carrier frequency (RadarConfig.fc_hz) - baseband 0 here
    value: '0'
  states: {}
- name: bandwidth_hz
  id: variable
  parameters:
    comment: Chirp bandwidth (RadarConfig.bandwidth_hz)
    value: 5e6
  states: {}
- name: pulse_width_s
  id: variable
  parameters:
    comment: Pulse width (RadarConfig.pulse_width_s)
    value: '20e-6'
  states: {}
- name: pri_s
  id: variable
  parameters:
    comment: Pulse repetition interval (RadarConfig.pri_s)
    value: '1e-3'
  states: {}
- name: n_pulse_samp
  id: variable
  parameters:
    comment: Samples per pulse
    value: int(pulse_width_s*samp_rate)
  states: {}
- name: n_pri_samp
  id: variable
  parameters:
    comment: Samples per PRI (the quiet window between pulses)
    value: int(pri_s*samp_rate)
  states: {}
- name: radar_taps
  id: epy_module
  parameters:
    source_code: |-
      """Radar waveform helpers for the GNU Radio flowgraphs.

      LEARNER TASK (05-roadmap.md stage 2 / 03-hardware.md 2.1-2.2):
      implement chirp(), pulse_vector() and matched() below so the
      flowgraphs can be generated and run. These mirror
      src/radar/signal_gen.py. All functions must return numpy complex128
      arrays; GRC converts them to gr_complex. See
      docs/training/01-physics.md section 2 (LFM) for the math.
      """

      import numpy as np


      def chirp(samp_rate=20e6, pulse_width_s=20e-6, bandwidth_hz=5e6, fc_hz=0.0):
          """Complex analytic LFM chirp, one pulse of fast-time samples.

          slope = bandwidth_hz / pulse_width_s
          return np.exp(1j * 2 * np.pi * (fc_hz * t + 0.5 * slope * t**2))
          with t = arange(int(pulse_width_s*samp_rate)) / samp_rate.
          """
          raise NotImplementedError(
              'Implement chirp() (05-roadmap.md stage 2)')


      def pulse_vector(samp_rate=20e6, pulse_width_s=20e-6, pri_s=1e-3,
                       bandwidth_hz=5e6, fc_hz=0.0):
          """One PRI: LFM chirp followed by the quiet window (zeros).

          np.concatenate([chirp(...), np.zeros(n_pri - n_pulse)]).
          """
          raise NotImplementedError(
              'Implement pulse_vector() (05-roadmap.md stage 2)')


      def matched(samp_rate=20e6, pulse_width_s=20e-6, bandwidth_hz=5e6):
          """Matched-filter taps: conjugated, time-reversed chirp.

          np.conj(chirp(...)[::-1]). Convolving with the echo gives the
          compressed pulse (range resolution c/(2B)).
          """
          raise NotImplementedError(
              'Implement matched() (05-roadmap.md stage 4)')
    comment: Radar waveform helpers (pulse_vector, matched)
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Pulsed LFM chirp = transmit waveform (signal_gen.transmit_waveform)
    repeat: 'True'
    type: complex
    vector: radar_taps.pulse_vector()
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Limit the flowgraph to the real sample rate (no CPU runaway)
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: '"TX pulsed chirp (I) / (Q)"'
    size: '4096'
    srate: samp_rate
    ymin: '-1.5'
    ymax: '1.5'
    gui_hint: 1,0,1,1
    label1: TX I
    label2: TX Q
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"TX spectrum"'
    fftsize: '1024'
    fc: fc
    bw: samp_rate
    gui_hint: 0,0,1,1
  states: {}

connections:
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
